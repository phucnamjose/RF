# IAR project RF.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S105C6 STM8S105C6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: $PROJ_DIR$; Lib\STM8S_StdPeriph_Driver\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: RF.srec
  ILINK.IlinkOutputFile: RF.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group Lib
    Lib/STM8S_StdPeriph_Driver/src/: stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_itc.c stm8s_iwdg.c stm8s_rst.c stm8s_spi.c stm8s_tim1.c stm8s_tim2.c stm8s_tim4.c stm8s_uart2.c stm8s_wwdg.c
  group User
    ./: main.c my_board.c stm8s_it.c uart2_user.c
