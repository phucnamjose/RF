<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>0</debug>
  </configuration>
  <group>
    <name>Lib</name>
    <file>
      <name>$PROJ_DIR$\Lib\STM8S_StdPeriph_Driver\src\stm8s_clk.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Lib\STM8S_StdPeriph_Driver\src\stm8s_exti.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Lib\STM8S_StdPeriph_Driver\src\stm8s_flash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Lib\STM8S_StdPeriph_Driver\src\stm8s_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Lib\STM8S_StdPeriph_Driver\src\stm8s_itc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Lib\STM8S_StdPeriph_Driver\src\stm8s_iwdg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Lib\STM8S_StdPeriph_Driver\src\stm8s_rst.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Lib\STM8S_StdPeriph_Driver\src\stm8s_spi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Lib\STM8S_StdPeriph_Driver\src\stm8s_tim1.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Lib\STM8S_StdPeriph_Driver\src\stm8s_tim2.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Lib\STM8S_StdPeriph_Driver\src\stm8s_tim4.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Lib\STM8S_StdPeriph_Driver\src\stm8s_uart2.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Lib\STM8S_StdPeriph_Driver\src\stm8s_wwdg.c</name>
    </file>
  </group>
  <group>
    <name>User</name>
    <file>
      <name>$PROJ_DIR$\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\my_board.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\stm8s_it.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\uart2_user.c</name>
    </file>
  </group>
</project>


